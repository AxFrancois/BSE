# Keil uVision project BSE_TP4.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: BSE_TP4
  c flags: SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 TP4_BSE_Lib_Config_Globale.c TP4_BSE_Lib_Divers.C TP4_BSE_Main.C
