# Keil uVision project BSE_TP2.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: BSE_TP1
  c flags: SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 TP2_BSE_Lib_Divers.C TP2_BSE_Lib_Config_Globale.c TP2_BSE_Main.c
